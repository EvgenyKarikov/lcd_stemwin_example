<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32l475_pandora_rtx.ewp</path>
  </project>
  <batchBuild />
</workspace>
